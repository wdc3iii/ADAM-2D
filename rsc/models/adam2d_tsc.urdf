Commit message: inbetween commit"

File: rsc/models/adam2d_tsc.urdf (robot description, URDF)
Before this commit: robot adam, 24 links, 23 joints
Links:
- link xslide: mass 0.00001 -> 0.0000001
- link zslide: mass 0.00001 -> 0.000000001
